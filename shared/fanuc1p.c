#include "fanuc1p.h"

int f1p_build_levels(uint8_t *lv, int max, uint32_t req, int req_bits, int lead, int tail, int idle) {
  int n = 0;
  idle  = idle ? 1 : 0;
  if(req_bits > 32) {
    req_bits = 32;
  }
  for(int i = 0; i < lead && n < max; i++) {
    lv[n++] = idle;
  }
  for(int i = 0; i < req_bits && n < max; i++) {
    lv[n++] = (req >> i) & 1;
  }
  for(int i = 0; i < tail && n < max; i++) {
    lv[n++] = idle;
  }
  return n;
}

int f1p_decode(const uint16_t *t, int n, float ticks_per_bit, int idle, uint8_t *bits, int maxbits) {
  int nb    = 0;
  int level = idle ? 0 : 1;  // level after the first edge
  if(n <= 0 || ticks_per_bit <= 0.0f) {
    return 0;
  }
  for(int i = 1; i < n && nb < maxbits; i++) {
    uint16_t dt = (uint16_t)(t[i] - t[i - 1]);
    int k       = (int)((float)dt / ticks_per_bit + 0.5f);
    if(k < 1) {
      k = 1;
    }
    for(int j = 0; j < k && nb < maxbits; j++) {
      bits[nb++] = level;
    }
    level = !level;
  }
  // after the last edge the line holds its level
  while(nb < maxbits) {
    bits[nb++] = level;
  }
  return nb;
}

uint32_t f1p_field(const uint8_t *bits, int nbits, int off, int len, int lsb_first) {
  uint32_t v = 0;
  if(len > 32) {
    len = 32;
  }
  for(int i = 0; i < len; i++) {
    int k    = off + i;
    uint32_t b = (k >= 0 && k < nbits) ? (bits[k] & 1) : 0;
    if(lsb_first) {
      v |= b << i;
    } else {
      v = (v << 1) | b;
    }
  }
  return v;
}

int f1p_format(char *out, int max, const uint8_t *bits, int nbits, int group) {
  int n = 0;
  for(int i = 0; i < nbits && n < max - 2; i++) {
    if(group > 0 && i > 0 && (i % group) == 0) {
      out[n++] = ' ';
    }
    out[n++] = bits[i] ? '1' : '0';
  }
  if(max > 0) {
    out[n < max ? n : max - 1] = 0;
  }
  return n;
}

uint8_t f1p_crc5(const uint8_t *bits, int n) {
  uint8_t r = 0;
  for(int i = 0; i < n; i++) {
    int fb = ((r >> 4) ^ bits[i]) & 1;
    r      = (r << 1) & 31;
    if(fb) {
      r ^= F1P_CRC_POLY;
    }
  }
  return r;
}

int f1p_frame(const uint8_t *bits, int nbits, f1p_frame_t *f) {
  for(int k = 0; k < 5; k++) {
    f->w[k] = 0;
    for(int i = 0; i < 16; i++) {
      int b = 1 + 19 * k + i;
      f->w[k] |= (uint16_t)((b < nbits ? bits[b] & 1 : 0) << i);
    }
  }
  f->pos   = (uint32_t)(f->w[0] >> 8) | ((uint32_t)f->w[1] << 8);
  f->turns = (int16_t)f->w[2];
  f->com   = (uint8_t)(f->w[3] & 0xff);
  if(nbits < F1P_FRAME_BITS) {
    f->crc = f->crc_rx = 0;
    return F1P_SHORT;
  }
  f->crc    = f1p_crc5(bits, 95);
  f->crc_rx = 0;
  for(int i = 0; i < 5; i++) {
    f->crc_rx = (uint8_t)((f->crc_rx << 1) | (bits[95 + i] & 1));
  }
  int sync = bits[0] == 0;
  for(int k = 0; k < 5; k++) {
    int s = 17 + 19 * k;
    sync  = sync && bits[s] == 1 && bits[s + 1] == 1 && (k == 4 || bits[s + 2] == 0);
  }
  if(!sync) {
    return F1P_SYNC;
  }
  return f->crc == f->crc_rx ? F1P_OK : F1P_CRC;
}

int f1p_frame_bit(const f1p_frame_t *f, int bit) {
  int b = bit - 1;
  if(b < 0 || b % 19 >= 16 || b / 19 > 4) {
    return -1;
  }
  return (f->w[b / 19] >> (b % 19)) & 1;
}

int f1p_decode_packed(const uint16_t *t, int n, float ticks_per_bit, int idle, uint32_t *w, int maxbits) {
  for(int i = 0; i < F1P_PACKED_WORDS; i++) {
    w[i] = 0;
  }
  if(n <= 0 || ticks_per_bit <= 0.0f) {
    return 0;
  }
  if(maxbits > F1P_MAX_BITS) {
    maxbits = F1P_MAX_BITS;
  }
  uint32_t inv = (uint32_t)(65536.0f / ticks_per_bit + 0.5f);  // bits per tick, 16.16
  int level    = idle ? 0 : 1;                                  // level after the first edge
  int nb       = 0;
  for(int i = 1; i <= n && nb < maxbits; i++) {
    int k;
    if(i < n) {
      k = (int)(((uint32_t)(uint16_t)(t[i] - t[i - 1]) * inv + 32768u) >> 16);
      if(k < 1) {
        k = 1;
      }
    } else {
      k = maxbits;  // after the last edge the line holds its level
    }
    if(k > maxbits - nb) {
      k = maxbits - nb;
    }
    if(level) {
      int b = nb, c = k;
      while(c > 0) {
        int o    = b & 31;
        int m    = c < 32 - o ? c : 32 - o;
        uint32_t mask = m == 32 ? 0xffffffffu : ((1u << m) - 1u);
        w[b >> 5] |= mask << o;
        b += m;
        c -= m;
      }
    }
    nb += k;
    level = !level;
  }
  return nb;
}

// CRC-5 0x0B over 8 bits MSB first: r = crc5_tab[(r << 3) ^ byte]
static const uint8_t crc5_tab[256] = {
  0x00, 0x0b, 0x16, 0x1d, 0x07, 0x0c, 0x11, 0x1a, 0x0e, 0x05, 0x18, 0x13, 0x09, 0x02, 0x1f, 0x14,
  0x1c, 0x17, 0x0a, 0x01, 0x1b, 0x10, 0x0d, 0x06, 0x12, 0x19, 0x04, 0x0f, 0x15, 0x1e, 0x03, 0x08,
  0x13, 0x18, 0x05, 0x0e, 0x14, 0x1f, 0x02, 0x09, 0x1d, 0x16, 0x0b, 0x00, 0x1a, 0x11, 0x0c, 0x07,
  0x0f, 0x04, 0x19, 0x12, 0x08, 0x03, 0x1e, 0x15, 0x01, 0x0a, 0x17, 0x1c, 0x06, 0x0d, 0x10, 0x1b,
  0x0d, 0x06, 0x1b, 0x10, 0x0a, 0x01, 0x1c, 0x17, 0x03, 0x08, 0x15, 0x1e, 0x04, 0x0f, 0x12, 0x19,
  0x11, 0x1a, 0x07, 0x0c, 0x16, 0x1d, 0x00, 0x0b, 0x1f, 0x14, 0x09, 0x02, 0x18, 0x13, 0x0e, 0x05,
  0x1e, 0x15, 0x08, 0x03, 0x19, 0x12, 0x0f, 0x04, 0x10, 0x1b, 0x06, 0x0d, 0x17, 0x1c, 0x01, 0x0a,
  0x02, 0x09, 0x14, 0x1f, 0x05, 0x0e, 0x13, 0x18, 0x0c, 0x07, 0x1a, 0x11, 0x0b, 0x00, 0x1d, 0x16,
  0x1a, 0x11, 0x0c, 0x07, 0x1d, 0x16, 0x0b, 0x00, 0x14, 0x1f, 0x02, 0x09, 0x13, 0x18, 0x05, 0x0e,
  0x06, 0x0d, 0x10, 0x1b, 0x01, 0x0a, 0x17, 0x1c, 0x08, 0x03, 0x1e, 0x15, 0x0f, 0x04, 0x19, 0x12,
  0x09, 0x02, 0x1f, 0x14, 0x0e, 0x05, 0x18, 0x13, 0x07, 0x0c, 0x11, 0x1a, 0x00, 0x0b, 0x16, 0x1d,
  0x15, 0x1e, 0x03, 0x08, 0x12, 0x19, 0x04, 0x0f, 0x1b, 0x10, 0x0d, 0x06, 0x1c, 0x17, 0x0a, 0x01,
  0x17, 0x1c, 0x01, 0x0a, 0x10, 0x1b, 0x06, 0x0d, 0x19, 0x12, 0x0f, 0x04, 0x1e, 0x15, 0x08, 0x03,
  0x0b, 0x00, 0x1d, 0x16, 0x0c, 0x07, 0x1a, 0x11, 0x05, 0x0e, 0x13, 0x18, 0x02, 0x09, 0x14, 0x1f,
  0x04, 0x0f, 0x12, 0x19, 0x03, 0x08, 0x15, 0x1e, 0x0a, 0x01, 0x1c, 0x17, 0x0d, 0x06, 0x1b, 0x10,
  0x18, 0x13, 0x0e, 0x05, 0x1f, 0x14, 0x09, 0x02, 0x16, 0x1d, 0x00, 0x0b, 0x11, 0x1a, 0x07, 0x0c};
// the 8 bits reversed: the first received (the lowest) becomes the MSB
static const uint8_t rev8[256] = {
  0x00, 0x80, 0x40, 0xc0, 0x20, 0xa0, 0x60, 0xe0, 0x10, 0x90, 0x50, 0xd0, 0x30, 0xb0, 0x70, 0xf0,
  0x08, 0x88, 0x48, 0xc8, 0x28, 0xa8, 0x68, 0xe8, 0x18, 0x98, 0x58, 0xd8, 0x38, 0xb8, 0x78, 0xf8,
  0x04, 0x84, 0x44, 0xc4, 0x24, 0xa4, 0x64, 0xe4, 0x14, 0x94, 0x54, 0xd4, 0x34, 0xb4, 0x74, 0xf4,
  0x0c, 0x8c, 0x4c, 0xcc, 0x2c, 0xac, 0x6c, 0xec, 0x1c, 0x9c, 0x5c, 0xdc, 0x3c, 0xbc, 0x7c, 0xfc,
  0x02, 0x82, 0x42, 0xc2, 0x22, 0xa2, 0x62, 0xe2, 0x12, 0x92, 0x52, 0xd2, 0x32, 0xb2, 0x72, 0xf2,
  0x0a, 0x8a, 0x4a, 0xca, 0x2a, 0xaa, 0x6a, 0xea, 0x1a, 0x9a, 0x5a, 0xda, 0x3a, 0xba, 0x7a, 0xfa,
  0x06, 0x86, 0x46, 0xc6, 0x26, 0xa6, 0x66, 0xe6, 0x16, 0x96, 0x56, 0xd6, 0x36, 0xb6, 0x76, 0xf6,
  0x0e, 0x8e, 0x4e, 0xce, 0x2e, 0xae, 0x6e, 0xee, 0x1e, 0x9e, 0x5e, 0xde, 0x3e, 0xbe, 0x7e, 0xfe,
  0x01, 0x81, 0x41, 0xc1, 0x21, 0xa1, 0x61, 0xe1, 0x11, 0x91, 0x51, 0xd1, 0x31, 0xb1, 0x71, 0xf1,
  0x09, 0x89, 0x49, 0xc9, 0x29, 0xa9, 0x69, 0xe9, 0x19, 0x99, 0x59, 0xd9, 0x39, 0xb9, 0x79, 0xf9,
  0x05, 0x85, 0x45, 0xc5, 0x25, 0xa5, 0x65, 0xe5, 0x15, 0x95, 0x55, 0xd5, 0x35, 0xb5, 0x75, 0xf5,
  0x0d, 0x8d, 0x4d, 0xcd, 0x2d, 0xad, 0x6d, 0xed, 0x1d, 0x9d, 0x5d, 0xdd, 0x3d, 0xbd, 0x7d, 0xfd,
  0x03, 0x83, 0x43, 0xc3, 0x23, 0xa3, 0x63, 0xe3, 0x13, 0x93, 0x53, 0xd3, 0x33, 0xb3, 0x73, 0xf3,
  0x0b, 0x8b, 0x4b, 0xcb, 0x2b, 0xab, 0x6b, 0xeb, 0x1b, 0x9b, 0x5b, 0xdb, 0x3b, 0xbb, 0x7b, 0xfb,
  0x07, 0x87, 0x47, 0xc7, 0x27, 0xa7, 0x67, 0xe7, 0x17, 0x97, 0x57, 0xd7, 0x37, 0xb7, 0x77, 0xf7,
  0x0f, 0x8f, 0x4f, 0xcf, 0x2f, 0xaf, 0x6f, 0xef, 0x1f, 0x9f, 0x5f, 0xdf, 0x3f, 0xbf, 0x7f, 0xff};

static inline uint32_t bits_at(const uint32_t *w, int off, int len) {
  uint64_t v = (uint64_t)w[off >> 5] | ((uint64_t)w[(off >> 5) + 1] << 32);
  return (uint32_t)(v >> (off & 31)) & ((1u << len) - 1u);
}

int f1p_frame_packed(const uint32_t *w, int nbits, f1p_frame_t *f) {
  for(int k = 0; k < 5; k++) {
    f->w[k] = (uint16_t)bits_at(w, 1 + 19 * k, 16);
  }
  f->pos   = (uint32_t)(f->w[0] >> 8) | ((uint32_t)f->w[1] << 8);
  f->turns = (int16_t)f->w[2];
  f->com   = (uint8_t)(f->w[3] & 0xff);
  if(nbits < F1P_FRAME_BITS) {
    f->crc = f->crc_rx = 0;
    return F1P_SHORT;
  }
  uint8_t r = 0;
  int i     = 0;
  for(; i + 8 <= 95; i += 8) {
    r = crc5_tab[((r << 3) ^ rev8[bits_at(w, i, 8)]) & 0xff];
  }
  for(; i < 95; i++) {
    int fb = ((r >> 4) ^ f1p_bit_packed(w, i)) & 1;
    r      = (r << 1) & 31;
    if(fb) {
      r ^= F1P_CRC_POLY;
    }
  }
  f->crc    = r;
  f->crc_rx = 0;
  for(int i = 0; i < 5; i++) {
    f->crc_rx = (uint8_t)((f->crc_rx << 1) | f1p_bit_packed(w, 95 + i));
  }
  int sync = f1p_bit_packed(w, 0) == 0 && bits_at(w, 93, 2) == 3;
  for(int k = 0; k < 4; k++) {
    sync = sync && bits_at(w, 17 + 19 * k, 3) == 3;  // 1 1 0, first bit lowest
  }
  if(!sync) {
    return F1P_SYNC;
  }
  return f->crc == f->crc_rx ? F1P_OK : F1P_CRC;
}
